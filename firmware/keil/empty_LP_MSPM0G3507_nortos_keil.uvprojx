# Keil uVision project empty_LP_MSPM0G3507_nortos_keil.uvprojx, settings and files
target empty_LP_MSPM0G3507_nortos_keil (6210000::V6.21::ARMCLANG)
  device: MSPM0G3507 Texas Instruments
  pack: TexasInstruments.MSPM0G1X0X_G3X0X_DFP.1.3.1
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20200000,0x00008000) IROM(0x00000000,0x00020000) IROM2(0x00400000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: empty_LP_MSPM0G3507_nortos_keil +hex
  BeforeMake: cmd.exe /C "%MSPM0_SDK_INSTALL_DIR%\tools\keil\syscfg.bat" "$P" empty.syscfg
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0G3507__
  c include: %MSPM0_SDK_INSTALL_DIR%\source\third_party\CMSIS\Core\Include;%MSPM0_SDK_INSTALL_DIR%\source;..\BSP;..\BSP\OLED
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x400000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20200000 size 0x8000
  scatter file: .\mspm0g3507.sct
  group Source
    ../: empty.c empty.syscfg ti_msp_dl_config.h ti_msp_dl_config.c board.c board.h
    ./: startup_mspm0g350x_uvision.s
  group Driverlib
    %MSPM0_SDK_INSTALL_DIR%/source/ti/driverlib/lib/keil/m0p/mspm0g1x0x_g3x0x/: driverlib.a
  group BSP
    ../BSP/: bsp_bmp180.c bsp_bmp180.h dht11.c dht11.h bsp_gy30.c bsp_gy30.h bsp_bluetooth.c bsp_bluetooth.h bsp_key.c bsp_key.h png.c png.h
    ../BSP/OLED/: oled.c oled.h
